# Keil uVision project atk_f407.uvprojx, settings and files
target SRAM (6240000::V6.24::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: atk_f407 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,DATA_IN_ExtSRAM
  c include: ..\..\User;..\..\App\bsp;..\..\App\can_motor;..\..\App\control;..\..\App\eeprom;..\..\App\interp;..\..\App\safety;..\..\App\udp_proto;..\..\Drivers;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Middlewares;..\..\Middlewares\arch;..\..\Middlewares\src\include;..\..\Middlewares\src\include\lwip;..\..\Middlewares\src\include\ipv4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group User
    ../../User/: main.c stm32f4xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_can.c stm32f4xx_hal_eth.c stm32f4xx_hal_i2c.c stm32f4xx_hal_iwdg.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/SYS_INFO/: sys_info.c
    ../../Drivers/BSP/LCD_STATUS/: lcd_status.c
  group Middlewares/USMART
    ../../Middlewares/USMART/: usmart.c usmart_config.c usmart_port.c usmart_str.c
  group App/bsp
    ../../App/bsp/: ethernet.c sram.c
  group App/can_motor
    ../../App/can_motor/: can_motor.c
  group App/control
    ../../App/control/: control_isr.c tasks.c
  group App/eeprom
    ../../App/eeprom/: eeprom.c
  group App/interp
    ../../App/interp/: interpolation.c
  group App/safety
    ../../App/safety/: safety.c
  group App/udp_proto
    ../../App/udp_proto/: udp_protocol.c
  group Core/User
    ../../User/: stm32f4xx_hal_msp.c mpu_config.c syscalls.c sysmem.c
  group Middlewares/LwIP/arch
    ../../Middlewares/arch/: ethernetif.c lwip_comm.c sys_arch.c udp_net.c
  group Middlewares/LwIP/core
    ../../Middlewares/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/LwIP/core/ipv4
    ../../Middlewares/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/LwIP/netif
    ../../Middlewares/src/netif/: ethernet.c
  group Readme
    ../../: readme.txt
